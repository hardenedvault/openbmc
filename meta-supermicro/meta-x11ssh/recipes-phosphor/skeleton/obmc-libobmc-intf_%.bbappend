FILESEXTRAPATHS:prepend:x11ssh := "${THISDIR}/${PN}:"
